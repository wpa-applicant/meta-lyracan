SUMMARY = "CAN protocol project for Lyra"
DESCRIPTION = "CAN protocol project for Lyra"
LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

S = "${WORKDIR}"

DEPENDS += " can-utils "

SRC_URI += " file://main.cpp "
